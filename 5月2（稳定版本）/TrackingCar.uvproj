# Keil uVision project TrackingCar.uvproj, settings and files
target Target (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: TrackingCar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c main.h
  group Bin
    ./: STARTUP.A51 L298N.c L298N.h TCRT5000.c TCRT5000.h
